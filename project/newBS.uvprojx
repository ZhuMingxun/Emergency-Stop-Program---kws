# Keil uVision project newBS.uvprojx, settings and files
target newBS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: newBS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o bs_fw.bin objects\newBS.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\src\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24;..\src\lpc_core\lpc_chip\chip_common;..\src\lpc_core\lpc_chip\chip_11xx;..\src\lpc_core\lpc_chip\chip_11xx\config_11cxx;..\src\CMSIS;..\src\lpc_core\lpc_board\board_common;..\src\user_system;..\src\device
  asm define: NO_CRP
  asm misc: --cpreproc
  asm include: ..\src\lpc_core\lpc_board\boards_11xx\nxp_lpcxpresso_11c24;..\src\lpc_core\lpc_chip\chip_11xx\config_11cxx
  memory RVCT4: ROM 0x2000 size 0x6000
  memory RVCT9: RAM 0x100000f0 size 0x1f10
  group app
    ../src/user_application/: main.c
  group user_system
    ../src/user_system/: system.c
  group YY
    ../src/device/: ambe.c speak.c
  group device
    ../src/device/: can.c dataio.c t16b0.c adc.c AT24C16.c BspIapDriver.c watchDog.c
  group StartUp
    ../src/startup_code/: sysinit.c keil_startup_lpc11xx.s
  group lib
    ../src/lpc_core/lpc_chip/chip_11xx/keil_output/chip_11cxx_lib/: chip_11cxx_lib.lib
    ../src/lpc_core/lpc_board/boards_11xx/nxp_lpcxpresso_11c24/keil_output/: board_nxp_lpcxpresso_11c24.lib
  group Doc
    ../doc/: AT24C16存储空间分配.txt log.txt kws.txt
software components: CMSIS:CORE 5.0.1
