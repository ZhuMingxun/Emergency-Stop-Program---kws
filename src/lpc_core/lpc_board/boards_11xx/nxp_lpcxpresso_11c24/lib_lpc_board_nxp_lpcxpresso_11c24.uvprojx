# Keil uVision project lib_lpc_board_nxp_lpcxpresso_11c24.uvprojx, settings and files
target nxp_lpcxpresso_11c24 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: board_nxp_lpcxpresso_11c24 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\CMSIS;..\..\..\lpc_chip\chip_11xx;..\..\..\lpc_chip\chip_common;..\..\..\lpc_chip\chip_11xx\config_11cxx;..\nxp_lpcxpresso_11c24;..\..\board_common
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group board_nxp_lpcxpresso_11c24
    ./: board_sysinit.c board.c
software components: CMSIS:CORE 5.0.1
